# Keil uVision project Project.uvprojx, settings and files
target STM32F4xx-Nucleo (ARM-ADS)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F401RE-Nucleo
  AfterMake: fromelf --bin -o STM32F4xx-Nucleo\STM32F401RE-Nucleo.bin STM32F4xx-Nucleo\STM32F401RE-Nucleo.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,
  c misc: --C99
  c include: ..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Inc;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F4xx_Nucleo;..\..\..\..\..\..\Drivers\BSP\Components\M24LR;..\..\..\..\..\..\Drivers\BSP\x_nucleo_nfc02a1;..\..\..\..\..\..\Middlewares\ST\lib_nfc\lib_NDEF\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Applications/MDK-ARM
    ./: startup_stm32f401xe.s
  group Applications/User
    ../../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Components/M24LR
    ../../../../../../Drivers/BSP/Components/M24LR/: m24lr.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx_Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-NFC01A1
    ../../../../../../Drivers/BSP/X_Nucleo_NFC02A1/: x_nucleo_nfc02a1.c x_nucleo_nfc02a1_nfctag.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_pwr.c
  group Middlewares
    ../../../../../../Middlewares/ST/lib_nfc/lib_NDEF/src/: lib_NDEF.c lib_NDEF_AAR.c lib_NDEF_Email.c lib_NDEF_Geo.c lib_NDEF_MyApp.c lib_NDEF_SMS.c lib_NDEF_Text.c lib_NDEF_URI.c lib_NDEF_Vcard.c tagtype5_wrapper.c
